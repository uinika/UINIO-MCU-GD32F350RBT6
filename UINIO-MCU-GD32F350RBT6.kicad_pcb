# Repository uinika/UINIO-MCU-GD32F350RBT6

File README.md:

# UINIO-MCU-GD32F350RBT6 核心板

[**UINIO-MCU-GD32F350RBT6**](https://gitee.com/uinika/UINIO-MCU-GD32F350RBT6) 是一款基于 [**兆易创新**](https://www.gigadevice.com.cn/) 国产 **LQFP64** 封装的 **GD32F350RBT6** 微控制器的核心板电路设计，该微控制器基于 **ARM Cortex-M4** 内核架构，主频高达 `108MHz`，片上载有 `128K` 容量的 Flash 存储器，以及 `16K` 的 SRAM 存储器，并且各拥有 2 组 `USART`、`I2C`、`SPI`，以及 1 组 `I2S`、`12 位 ADC`、`12 位 DAC`，同时支持 **USB 2.0 FS OTG** 协议，总体上属于 GPIO 引脚数量较多，但是外设资源有所取舍的主控芯片产品。

> **注意**：相比较于采用 **ARM Cortex-M3** 内核架构的 **GD32F103C8T6** 等产品，使用 **ARM Cortex-M4** 内核的 **GD32F350RBT6** 携带有浮点计算单元（**FPU**，Float Point Unit），在处理数学计算时能够大幅度提升运算性能。

## 启动配置

**UINIO-MCU-STM32F401CCU6** 通过板载 `BOOT0` 按钮和**用户选项字节** `BOOT1_n` 位来配置启动方式，默认情况下是从片上的 Flash 闪存进行启动，具体的配置信息可以参见下表：

| BOOT0 | BOOT1_n | 启动方式                 |
| :---: | :-----: | :----------------------- |
|  `0`  |   `X`   | 片上 Flash 闪存          |
|  `1`  |   `0`   | 系统存储器/ISP           |
|  `1`  |   `1`   | 片上 SRAM 静态随机存储器 |

## 设计概要

1. 引出了兆易创新 **GD32F350RBT6** 型微控制器上面的全部 GPIO 引脚资源；
2. 单独提供有四线制的 **SWD** 下载接口，便于快速与 [UINIO-DAP-Link](http://uinio.com/Project/UINIO-DAP-Link) 建立连接；
3. 分别使用了 `8MHz` 与 `32.768KHz` 两枚贴片晶振作为系统外部时钟与实时时钟；
4. 板载一枚 **BOOT0** 启动配置按钮，以及一枚 **NRST** 复位按钮；
5. 模拟电源引脚 `VDDA` 使用了对 `100Mhz` 高频杂散信号存在 `1KΩ` 阻抗的**磁珠**进行单点接地；

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 UINIO-MCU-GD32F350RBT6 开源项目提供了如下一系列技术参考资料：

1. [《兆易创新 UINIO-MCU-GD32 标准库开发指南》](http://uinio.com/Project/UINIO-MCU-GD32/)
2. [《ARM 调试工具 UINIO-DAP-Link 应用详解》](http://uinio.com/Project/UINIO-DAP-Link/)
3. [《BOM 交互式物料清单与 PCB 布线在线预览》](http://uinio.com/archives/BOM/UINIO-MCU-GD32F350RBT6.html)

## KiCad design UINIO-MCU-GD32F350RBT6.kicad_pcb

Parts:
C1, C3: 1uF; C_0603_1608Metric
C2, C4, C5, C7, C11: 0.1uF; C_0603_1608Metric
C6, C10: 20pF; C_0603_1608Metric
C8, C9: 10pF; C_0603_1608Metric
D1: LED_Red; LED_0603_1608Metric
J1, J2: Conn_01x32_Pin; PinHeader_1x32_P2.54mm_Vertical
J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
L1: 1KΩ 100Mhz; L_0603_1608Metric
R1: 2K; R_0603_1608Metric
R2, R3, R5, R6: 10K; R_0603_1608Metric
R7, R8: 50R; R_0603_1608Metric
SW1: BOOT0; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.7
SW2: NRST; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.7
U1: ME6211C33M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U2: GD32F350RBT6; LQFP-64_L10.0-W10.0-P0.50-LS12.0-BL
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
Y1: 32.768KHz; CRYSTAL-FC135-32.768
Y2: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/BOOT0: C2.2, J2.5, R2.1, U2.60 (BOOT0)
/NRST: C7.1, J1.7, R3.2, SW2.1, SW2.2, U2.7 (NRST)
/PA0: J1.14, U2.14 (PA0)
/PA1: J1.15, U2.15 (PA1)
/PA2: J1.16, U2.16 (PA2)
/PA3: J1.17, U2.17 (PA3)
/PA4: J1.20, U2.20 (PA4)
/PA5: J1.21, U2.21 (PA5)
/PA6: J1.22, U2.22 (PA6)
/PA7: J1.23, U2.23 (PA7)
/PA8: J2.24, U2.41 (PA8)
/PA9: J2.23, U2.42 (PA9)
/PA10: J2.22, U2.43 (PA10)
/PA12: J2.20, R7.1, U2.45 (PA12)
/PA13/SWDIO: J2.19, J3.3, R6.1, U2.46 (PA13)
/PA14/SWCLK: J2.16, J3.2, R5.2, U2.49 (PA14)
/PA15: J2.15, U2.50 (PA15)
/PB0: J1.26, U2.26 (PB0)
/PB1: J1.27, U2.27 (PB1)
/PB2: J1.28, U2.28 (PB2)
/PB3: J2.10, U2.55 (PB3)
/PB4: J2.9, U2.56 (PB4)
/PB5: J2.8, U2.57 (PB5)
/PB6: J2.7, U2.58 (PB6)
/PB7: J2.6, U2.59 (PB7)
/PB8: J2.4, U2.61 (PB8)
/PB9: J2.3, U2.62 (PB9)
/PB10: J1.29, U2.29 (PB10)
/PB11: J1.30, U2.30 (PB11)
/PB12: J2.32, U2.33 (PB12)
/PB13: J2.31, U2.34 (PB13)
/PB14: J2.30, U2.35 (PB14)
/PB15: J2.29, U2.36 (PB15)
/PC0: J1.8, U2.8 (PC0)
/PC1: J1.9, U2.9 (PC1)
/PC2: J1.10, U2.10 (PC2)
/PC3: J1.11, U2.11 (PC3)
/PC4: J1.24, U2.24 (PC4)
/PC5: J1.25, U2.25 (PC5)
/PC6: J2.28, U2.37 (PC6)
/PC7: J2.27, U2.38 (PC7)
/PC8: J2.26, U2.39 (PC8)
/PC9: J2.25, U2.40 (PC9)
/PC10: J2.14, U2.51 (PC10)
/PC11: J2.13, U2.52 (PC11)
/PC12: J2.12, U2.53 (PC12)
/PC13: J1.6, U2.2 (PC13)
/PD2: J2.11, U2.54 (PD2)
/PF0: U2.5 (PF0-OSCIN), Y2.3
/PF1: U2.6 (PF1-OSCOUT), Y2.1
/PF4: J1.18, U2.18 (PF4)
/PF5: J1.19, U2.19 (PF5)
/PF6: J2.18, U2.47 (PF6)
/PF7: J2.17, U2.48 (PF7)
/USB_Data+: R7.2, USB1.A6 (DP1), USB1.B6 (DP2)
/VBAT: C11.1, J1.5, U2.1 (VBAT)
/VDD_3.3V: C3.2, C4.2, C5.2, J1.4, J1.12, J1.31, J2.2, J3.4, R1.2, R3.1, R6.2, SW1.3, SW1.4, U1.5 (Vout), U2.13 (VDDA), U2.32 (VDD), U2.64 (VDD)
/VDD_5V: C1.2, J1.2, U1.1 (Vin), U1.3 (CE), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/VSSA: L1.2, U2.12 (VSSA)
unnamed: C6.2, Y2.4
unnamed: C10.2, Y2.2
unnamed: D1.2 (A), R1.1
unnamed: C8.2, U2.3 (PC14-OSC32IN), Y1.2 (GND)
unnamed: C9.2, U2.4 (PC15-OSC32OUT), Y1.1

Notes on the sheet:
USB Type-C 接口电路
32Pin 2.54mm 排针
GD32F350RBT6 最小系统
SWD 调试接口
3.3V 线性稳压电路

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
Board: 2 copper layers, 88.1 x 25.4 mm, 36 parts (2 on the bottom side), 69 nets.

Other parts of the board:
HOLE1, HOLE2, HOLE3, HOLE4: Hole-1mm
R10, R11: 5.1K; R_0603_1608Metric

## Commit log

2022-12-08 Initializing the project
2022-12-08 Initializing the project.
2022-12-09 Update schematic diagram.
2022-12-09 Finish PCB layout.
2022-12-12 Release UINIO-MCU-GD32F350RBT6 version 1.0.0.
2023-06-28 Upgrade version 2.0.0.
2023-06-28 Release UINIO-MCU-GD32F350RBT6 version 2.0.0.
2023-07-11 Update README.md.
2023-08-30 Release UINIO-MCU-GD32F350RBT6 version 3.0.0.
2023-12-22 Add Keil-Template-GD32F350RBT6.
2023-12-22 Rename Keil-GD32F350RBT6.
2023-12-22 Add Keil-GD32F350RBT6.
2024-01-11 Release UINIO-MCU-GD32F350RBT6 version 3.0.1.
2024-01-31 Release UINIO-MCU-GD32F350RBT6 version 3.1.1.
2024-02-07 Release UINIO-MCU-GD32F350RBT6 version 3.2.0.
2024-02-11 Added Chinese language support for Keil project.
2024-02-12 Fix bug.
2024-02-12 Update Git ignore.
2024-02-13 Refactoring sample code.
2024-02-21 Add example code.
2024-03-04 Update examples.
2024-03-07 Update example.
2024-03-07 Update LED example base on bitband.
2024-03-16 Update example code.
2024-04-12 Release UINIO-MCU-GD32F350RBT6 version 3.3.0.
