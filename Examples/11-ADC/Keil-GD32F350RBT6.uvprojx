# Keil uVision project Keil-GD32F350RBT6.uvprojx, settings and files
target Keil-GD32F350RBT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Keil-GD32F350RBT6.hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F3X0,GD32F350
  c include: .\Sources;.\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F3x0\Include;.\Firmware\GD32F3x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
    ./Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Drivers
    ./Drivers/LED/: LED.c LED.h
    ./Drivers/SysTick/: SysTick.c SysTick.h
    ./Drivers/BitBand/: BitBand.h
    ./Drivers/Key/: Key.c Key.h
    ./Drivers/USART/: USART.c USART.h
    ./Drivers/EXTI-Key/: EXTI-Key.c EXTI-Key.h
    ./Drivers/Timer-LED/: Timer-LED.c Timer-LED.h
    ./Drivers/PWM-LED/: PWM-LED.c PWM-LED.h
    ./Drivers/DMA/: DMA.c DMA.h
    ./Drivers/ADC/: ADC.c ADC.h
  group Firmware
    ./Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Documents
    ./Documents/: Readme.md
  group Sources
    ./Sources/: gd32f3x0_it.c main.c systick.c
